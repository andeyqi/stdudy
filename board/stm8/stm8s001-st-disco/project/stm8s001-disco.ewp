# IAR project stm8s001-disco.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S001J3 STM8S001J3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S001
  ICCSTM8.CCIncludePath2: ..\libraries\inc; ..\app
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8s001-disco.srec
  ILINK.IlinkOutputFile: stm8s001-disco.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../app/: main.c stm8s_it.c
  group libraies
    ../libraries/src/: stm8s_gpio.c
